# Keil uVision project led呼吸灯.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: led呼吸灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\pwm
  group USER
    ../User/: main.c
    ../User/pwm/: bsp_pwm.c bsp_pwm.h
  group FWLIB
    ../Libraries/: STARTUP.A51
