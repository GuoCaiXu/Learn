# Keil uVision project 超声波测距.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 超声波测距 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Libraries;..\User
  group USER
    ../User/: main.c
    ../User/hc_sr04/: bsp_hc_sr04.c bsp_hc_sr04.h
  group FWLIB
    ../Libraries/: STARTUP.A51 stc89cxx.c stc89cxx.h
