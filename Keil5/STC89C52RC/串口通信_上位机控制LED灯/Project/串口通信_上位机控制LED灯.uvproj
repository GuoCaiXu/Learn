# Keil uVision project 串口通信_上位机控制LED灯.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 串口通信_上位机控制LED灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Libraries;..\User
  group USER
    ../User/: main.c
    ../User/led/: bsp_led.c bsp_led.h
    ../User/uart/: bsp_uart.c bsp_uart.h
  group FWLIB
    ../Libraries/: STARTUP.A51 stc89cxx.c stc89cxx.h
