# Keil uVision project 按键点led灯.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 按键点led灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ../User/: main.c
  group FWLIB
    ../Libraries/: STARTUP.A51
