# Keil uVision project sg90.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 机械臂 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Libraries;..\User;..\User\key;..\User\sg90
  group USER
    ../User/: main.c
    ../User/sg90/: sg90.c
    ../User/key/: key.c
  group FWLIB
    ../Libraries/: STARTUP.A51 stc89cxx.c stc89cxx.h
