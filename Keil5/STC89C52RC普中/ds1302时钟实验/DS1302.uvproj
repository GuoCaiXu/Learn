# Keil uVision project DS1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\ds1302;.\App\smg
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group App
    ./App/smg/: smg.c
    ./App/ds1302/: ds1302.c
  group Public
    ./Public/: public.c
